IMAGE_INSTALL:append = " boot-benchmark"
IMAGE_INSTALL:append = " systemd-analyze"
